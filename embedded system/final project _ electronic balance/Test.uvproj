# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Test
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 0_01_12g.c EEPROM.c HX711.c LCD1602.c MAIN.C Sch51.c weight.c
